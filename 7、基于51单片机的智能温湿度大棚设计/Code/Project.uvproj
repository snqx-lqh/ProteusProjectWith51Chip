# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c main.h LCD1602.c LCD1602.h keyScan.c keyScan.h bsp_timer.c bsp_timer.h bsp_uart.c bsp_uart.h dht11.c dht11.h
